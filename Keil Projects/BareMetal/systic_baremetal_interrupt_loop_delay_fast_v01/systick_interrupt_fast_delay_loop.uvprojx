# Keil uVision project systick_interrupt_fast_delay_loop.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: systick_int_fast_delay_loop
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c startup_stm32f446xx.s stm32f4xx.h stm32f446xx.h system_stm32f4xx.c system_stm32f4xx.h
software components: CMSIS:CORE 6.1.0
